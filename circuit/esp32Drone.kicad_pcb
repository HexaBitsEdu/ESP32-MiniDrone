# Repository HexaBitsEdu/ESP32-MiniDrone

File README.md:

# ESP32-Drone :

### Top view :

### Bottom View

## KiCad design circuit/esp32Drone.kicad_pcb

Parts:
C1, C4, C5, C8, C11, C12, C13, C14, C15: 10UF-10V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C6, C9, C10, C16, C17, C18: 0.1UF-10V; C_01005_0402Metric
C3: 2.2NF; C_01005_0402Metric
C7: 10NF-25V; C_01005_0402Metric
D1: BAT60B; D_SOD-323_HandSoldering
D2: 3v6; D_MiniMELF
D3, D4, D5, D6: LED; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D7, D8, D9, D10: LL4148; D_MiniMELF
J1: USB_OTG; USB_Micro-B_Molex_47346-0001
J2, J3: Conn_01x09_Male; PinHeader_1x09_P1.27mm_Vertical
J4, J5, J6, J7, J8: Conn_01x02_Male; PinHeader_1x02_P1.27mm_Vertical
J9: Conn_01x26_Female; Hirose_FH12-26S-0.5SH_1x26-1MP_P0.50mm_Horizontal
L1: 330R at 100MHz; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Q1: AO3401A; SOT-23
Q2, Q3, Q4, Q5: AO3400A; SOT-23
R1, R2, R4: 82K-1%; R_01005_0402Metric
R3: 100K; R_01005_0402Metric
R5, R6, R7, R8, R9, R10, R11, R12, R13, R18, R19, R20, R21, R22, R23, R25: 10K; R_01005_0402Metric
R14, R15, R16, R17: 1K5; R_01005_0402Metric
R24: 0R; R_01005_0402Metric
SW1: SW_Push; SW_SPST_CK_RS282G05A3
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TestPoint; TestPoint_Pad_1.5x1.5mm
U1: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U2: AP2112K-3.3; SOT-23-5
U3: ESP32-S2-WROVER; MODULE_ESP32-S2-WROVER
U4: XC6206P2V8MR; SOT-23
U5: XC6206P1V8MR; SOT-23

Connections:
+1V8: C14.2, C17.2, J9.10, U5.2
+2V8: C15.2, C16.2, C18.2, J9.4, J9.11, U4.2
+3V3: C5.1, C6.2, C7.2, D2.1 (K), J3.8, L1.1, R5.1, R6.1, R7.1, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R19.1, U1.8 (VDDIO), U1.13 (VDD), U2.5 (VOUT)
+5V: C1.1, C12.2, C13.2, D1.2 (A), J3.9, Q1.2, R3.2, R14.2, U2.1 (VIN), U4.3, U5.3
+BATT: C4.1, D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), J4.1, J5.2, J6.2, J7.1, J8.1, Q1.3, R1.1, TP1.1, TP3.1, TP5.1, TP7.1
/ADC_BAT: R1.2, R2.1, U3.5 (IO02)
/AUX_SCL: J3.1, R7.2, U1.7 (AUX_SCL)
/AUX_SDA: J3.2, R6.2, U1.6 (AUX_SDA)
/BUZ_1: J2.9, U3.33 (IO39)
/BUZ_2: J3.3, U3.32 (IO38)
/CAM_HREF: J9.9, U3.17 (IO14)
/CAM_PCLK: J9.17, U3.23 (USB_D+)
/CAM_RESET: C11.2, J9.6, R19.2, U3.21 (IO18)
/CAM_VSYNC: J9.7, U3.16 (IO13)
/CAM_XCLC: J9.13, U3.19 (IO16)
/CAM_Y2: J9.19, U3.27 (IO33)
/CAM_Y3: J9.21, U3.40 (IO46)
/CAM_Y4: J9.22, U3.39 (IO45)
/CAM_Y5: J9.20, U3.36 (IO42)
/CAM_Y6: J9.18, U3.24 (IO21)
/CAM_Y7: J9.16, U3.22 (USB_D-)
/CAM_Y8: J9.14, U3.20 (IO17)
/CAM_Y9: J9.12, U3.18 (IO15)
/CP_RXD: J2.6, R12.1, U3.37 (TXD0)
/CP_TXD: J2.5, R13.1, U3.38 (RXD0)
/ESP_EN: C10.2, J2.2, R18.1, SW1.1, U3.41 (EN)
/ESP_IO0: J2.3, U3.3 (IO00)
/EXT_IO1: J2.4, U3.4 (IO01)
/I2C0_SCL: J9.5, R10.1, U1.23 (SCL), U3.13 (IO10)
/I2C0_SDA: J9.3, R11.1, U1.24 (SDA), U3.14 (IO11)
/I2C1_SCL: J2.7, R8.1, U3.35 (IO41)
/I2C1_SDA: J2.8, R9.1, U3.34 (IO40)
/LED_BLE: R15.2, U3.10 (IO07)
/LED_GRN: R17.2, U3.12 (IO09)
/LED_RED: R16.2, U3.11 (IO08)
/MOT_1: Q3.1 (G), R21.2, U3.8 (IO05)
/MOT_2: Q5.1 (G), R23.2, U3.9 (IO06)
/MOT_3: Q2.1 (G), R20.2, U3.7 (IO04)
/MOT_4: Q4.1 (G), R22.2, U3.6 (IO03)
/MPU_INT: R5.2, U1.12 (INT), U3.15 (IO12)
/SPI_CLK: J3.5, U3.30 (IO36)
/SPI_CS0: J3.7, U3.28 (IO34)
/SPI_MISO: J3.4, U3.31 (IO37)
/SPI_MOSI: J3.6, U3.29 (IO35)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.1, C7.1, C8.2, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C17.1, C18.1, D2.2 (A), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), J1.4 (ID), J1.5 (GND), J1.6 (Shield), J2.1, J4.2, J9.15, Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), R2.2, R4.2, R20.1, R21.1, R22.1, R23.1, R24.2, R25.2, SW1.2, U1.1 (CLKIN), U1.9 (AD0), U1.11 (FSYNC), U1.18 (GND), U2.2 (GND), U3.1 (GND), U3.26 (GND), U3.42 (GND), U3.43 (GND), U4.1, U5.1
GNDA: C16.1, J9.2, R24.1
unnamed: C2.2, U1.10 (REGOUT)
unnamed: C3.2, U1.20 (CPOUT)
unnamed: D3.2 (A), R14.1
unnamed: D4.2 (A), R15.1
unnamed: D5.2 (A), R16.1
unnamed: D6.2 (A), R17.1
unnamed: D7.2 (A), J5.1, Q2.3 (D), TP2.1
unnamed: D8.2 (A), J6.1, Q3.3 (D), TP4.1
unnamed: D9.2 (A), J7.2, Q4.3 (D), TP6.1
unnamed: D10.2 (A), J8.2, Q5.3 (D), TP8.1
unnamed: J9.8, R25.1
unnamed: R3.1, U2.3 (EN)
VBUS: D1.1 (K), J1.1 (VBUS), Q1.1, R4.1
VDD: C8.1, C9.2, L1.2, R18.2, U3.2 (3V3)

Notes on the sheet:
supply
IMU
CAMERA
motorDriver

Board: 2 copper layers, 40.0 x 40.0 mm, 82 parts (12 on the bottom side), 60 nets.

## Commit log

2021-10-19 add schematic and pcb file
2021-10-19 add README file and 3D View
2021-10-19 add README file
